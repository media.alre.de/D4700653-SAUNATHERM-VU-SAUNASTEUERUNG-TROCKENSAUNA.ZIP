Properties of the parts of a building model (IFC2X3)

# File
Description: Saunasteuerung für Trockensaunen, 30…120 °C, max. 9 kW, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: D4700653, Saunasteuerung für Trockensaunen, 30…120 °C, max. 9 kW
In: Raum
Description: Elektronische Saunasteuerung für Saunabaden „finnisch“ (trocken). Die Temperatureinstellung erfolgt stufenlos (+30…+120 °C). Die Ansteuerung des Ofens erfolgt mit einer gestuften Einzelphasensteuerung (Stufenabstand 2 K). Das Gerät verfügt über Schalter für Licht/Ventilator/Heizung, eine Vorwahluhr (12 Std. maximal), Leuchtanzeigen EIN/AUS und Heizen, Fühlerbruch/Fühlerschlußsicherung, Heizzeitbegrenzung (6h/12h/ohne), Anschlüsse für Fern-Ein-/Aus-Schaltung und Lastabwurf. Im Lieferumfang ist ein Temperaturfühler mit Sicherheitstemperaturbegrenzer (141 °C) und 3 m Silikonkabel enthalten. Eine Lasterweiterung ist mit den Leistungsschaltgeräten LG x/xx möglich. Licht, Ventilator und die interne Elektronik sind getrennt abgesichert.; Classification: EC001885 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: D4700653; ModelLabel: Saunatherm VU; GlobalTradeItemNumber: 4050528021946; ProductURL: https://alre.de/produkt_D4700653
Pset_Specification - NominalLength: 0.237 m; NominalWidth: 0.212 m; NominalDepth: 0.07 m; NetWeight: 1.336
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: Saunasteuerungsgerät; Zubehör: yes; ETIM-Klasse: EC001885; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-D4700653.pdf
